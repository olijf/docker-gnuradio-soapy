options:
  parameters:
    description: IEEE 802.15.4 Radio RxFlow
    generate_options: no_gui
    id: radio
    output_language: python
    realtime_scheduling: '1'
    title: Sniffer Flow
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1000000 * (2400 + 5 * (channel - 10))
  states: {}
- name: processor
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: antenna_source
  id: parameter
  parameters:
    type: str
    value: A_BALANCED
  states: {}
- name: arguments
  id: parameter
  parameters:
    type: str
    value: uri=ip:192.168.2.1
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: pcap_filename
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: channel
  id: parameter
  parameters:
    type: intx
    value: '11'
  states: {}
- name: device
  id: parameter
  parameters:
    type: str
    value: plutosdr
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(bandwidth)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: arguments
  states: {state: disabled}
- name: pcap_filename
  id: parameter
  parameters:
    type: str
    value: ./persistent/sensors.pcap
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    antenna0: antenna_source
    bandwidth0: int(bandwidth)
    center_freq0: int(freq)
    dc_removal0: 'False'
    dev_args: arguments
    driver: device
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: 'True'
    bandwidth: int(bandwidth)
    center_freq: freq
    samp_rate: int(samp_rate)
    type: fc32
  states: {state: disabled}

connections:
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [iio_pluto_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [soapy_custom_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [soapy_plutosdr_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
